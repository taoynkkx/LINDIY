# Keil uVision project lindiy.uvproj, settings and files
target STM32F072C8T6 (ARM-ADS)
  device: Cortex-M0 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M0") ESEL ELITTLE
  output: lindiy +hex
  c flags: OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER, STM32F072
  c misc: --C99
  c include: ..\KEIL4;..\..\src\lib\STM32F0_StdPeriph_Lib_V1.5.0\CMSIS\Include;..\..\src\lib\STM32F0_StdPeriph_Lib_V1.5.0\CMSIS\Device\ST\STM32F0xx\Include;..\..\src\lib\STM32F0_StdPeriph_Lib_V1.5.0\STM32F0xx_StdPeriph_Driver\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x4000
  group lib/CMSIS
    ../../src/lib/STM32F0_StdPeriph_Lib_V1.5.0/CMSIS/Device/ST/STM32F0xx/Source/Templates/arm/: startup_stm32f072.s
  group lib/STM32F0_StdPeriph_Lib
    ../../src/lib/STM32F0_StdPeriph_Lib_V1.5.0/STM32F0xx_StdPeriph_Driver/src/: stm32f0xx_adc.c stm32f0xx_can.c stm32f0xx_cec.c stm32f0xx_comp.c stm32f0xx_crc.c stm32f0xx_crs.c stm32f0xx_dac.c stm32f0xx_dbgmcu.c stm32f0xx_dma.c stm32f0xx_exti.c stm32f0xx_flash.c stm32f0xx_gpio.c stm32f0xx_i2c.c stm32f0xx_iwdg.c stm32f0xx_misc.c stm32f0xx_pwr.c stm32f0xx_rcc.c stm32f0xx_rtc.c stm32f0xx_spi.c stm32f0xx_syscfg.c stm32f0xx_tim.c stm32f0xx_usart.c stm32f0xx_wwdg.c
  group ide
    ./: main.c stm32f0xx_it.c system_stm32f0xx.c
